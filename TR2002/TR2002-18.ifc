Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 2018_01
Time: 2020-11-05T09:12:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.0.108 - Exporter 21.1.0.108 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 05 09:12:34 2020 * Host: AT-WS301 * Database: C:\Users\fhe\AppData\Local\Temp\13f7a6a2-bdec-47bf-950d-10134e773708\a5069097-2eab-4b93-b644-accac4762874\ifc * Database version: 5507 * Database creation date: Thu Nov 05 09:12:31 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 05 09:12:31 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 05 09:12:31 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 519 m
Sonstige - Angezeigte Werte: Bauherr; Einheitenformat: Projekt Status; Familie: Projektinformationen; Nummerierung: 2018_01; Projektausgabedatum: Projektadresse; Unternehmensname: Projekt Datum; Verfasser eMail: E-Mail; Verfasser Firma 1: AUTODESK GmbH; Verfasser PLZ Ort: Ort; Verfasser Strasse: Adresse; Verfasser Telefon: Telefon; Verfasser URL: www.Autodesk.de/BIM
Text - Bauherr: AUTODESK; Baustellenort: BAUORT; Baustellenstraße: BAUSTRASSE 1; Einlagezahl: 123-45; Gerichtsbezirk: GERICHTSBEZIRK; Grundstücksnummer: GR; Katastralgemeinde: KG; Kundenadresse: KUNDENSTRASSE 1; Kundenort: KUNDENORT; Kundentelefon: 0000-00000-1; Kundenzusatz: KUNDENZUSATZ

# IfcBuildingElementProxy: Familie1:Norm, Familie1:Norm:2409350
In: Default
Type - Material: Stahl
Type - Abhängigkeiten - Ist parametrisch: 0 m
Type - ID-Daten - Alternative Einheiten: TR2002-18; Modell: Ankermutter / anchor nut; Umbruch nur zwischen Parametern: Norm; URL: Stahlwerk Annahütte; Versatz unten: https://www.annahuette.com/
Type - Modelleigenschaften - Länge / length: 45,0 mm; Schlüsselweite / across flats: 36,0 mm; Stückgewicht / mass: 0,29 kg
Type - Sonstige - Familie: Allgemeines Modell; Ebene: Familie1
Type - Pset_BuildingElementProxyCommon - Reference: Norm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Stahlwerk Annahütte
Type - Pset_QuantityTakeOff - Reference: Norm
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 0.045 m; Depth: 0.045 m
Abhängigkeiten - Basis mit Rasterlinien verschieben: Keine; Länge: 0 m; Tragwerksverwendung: no; Verschieben mit Raster: 0 m
Abmessungen - Bedingung für gekrümmte Kante: 0.00495454 m2; IfcApplicationVersion: 0.0000391809 m3
Phasen - Durchschnittsmodul: Phase 2
Sonstige - Führungstyp: Familie1: Norm; Ist eine Referenz: Familie1: Norm; Verknüpfter Bezug: Familie1: Norm
